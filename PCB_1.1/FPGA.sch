File: PCB_1.1/FPGA.sch (KiCad schematic (older format))
At the start: 18 parts, among them P1 CONN_01X05, U6 LCMX02-640UHC-4TG144C

Commit message: PCB work.
Connections:
- wire segments 170 -> 90
